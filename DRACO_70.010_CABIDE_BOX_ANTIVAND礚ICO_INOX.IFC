Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_70.010_CABIDE_BOX_ANTIVANDÁLICO_INOX.IFC
Time: 2023-12-19T14:26:44
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Envolver1
In: Default Storey
PSet_Mass_Property - Mass Measure: 0.291653; Area Measure: 0.0149851 m2; Volume Measure: 0.0000364567 m3
